# Keil uVision project STM32-LwIP.uvprojx, settings and files
target STM32-LwIP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-LwIP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\lwip\src\api;..\..\lwip\src\arch;..\..\lwip\src\include;..\..\lwip\src\netif;..\..\lwip\src\include\ipv4;..\..\Source\inc;..\..\lwip\src;..\..\Source\uIP-1.0\uip;..\..\Source\uIP-APP;..\..\Source\uIP-1.0\apps\webserver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../Source/src/: main.c stm32f10x_it.c lwipdemo.c usart_printf.c loopback.c
  group Startup
    ../../Libraries/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_exti.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group lwip-arch
    ../../lwip/src/arch/: cc.h lwipopts.h perf.h ENC28J60.C SPI.C
  group lwip-netif
    ../../lwip/src/netif/: ethernetif.c etharp.c slipif.c
  group lwip-core
    ../../lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip-core-ipv4
    ../../lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group uip
    ../../Source/uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uip-app
    ../../Source/uIP-APP/: clock-arch.c tapdev.c tcp_client_demo.c tcp_demo.c tcp_server_demo.c udp_demo.c
    ../../Source/uIP-1.0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
software components: CMSIS:CORE 4.3.0
